# IAR project Chassis.ewp, settings and files
configuration Chassis (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ../simplelib/; ../simplelib/cmd; ../simplelib/can; ../simplelib/core; ../simplelib/flash; ../simplelib/utils; ../simplelib/module
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Chassis.hex
  ILINK.IlinkOutputFile: Chassis.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User/Movement
    ../Src/: chassis.c chassis_handle.c configure.c karman.c laser.c motordriver.c robomaster.c vec.c
  group Application/User/Point
    ../Src/: point.c point_parser.c
  group Application/User/Sensor
    ../Src/: vega.c
  group Application/User/Simplelib
    ../simplelib/can/: can_func.c can_utils.c
    ../simplelib/cmd/: cmd.c cmd_func.c
    ../simplelib/core/: flags.c
    ../simplelib/flash/: flash.c stmflash.c
    ../simplelib/utils/: hash.c utils.c
    ../simplelib/: simplelib.c
  group Application/User/System
    ../Src/: adc.c can.c dma.c gpio.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c sys.c usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
